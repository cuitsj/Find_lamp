<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x5BFB;&#x7684;&#x5C0F;&#x8F66;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


