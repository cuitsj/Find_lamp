<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Prj\IAR\&#x75Be;&#x5149;&#x961F;&#x4e0A;&#x4F4D;&#x673A;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


